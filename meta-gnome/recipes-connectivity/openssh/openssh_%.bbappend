# An ssh native client binary is needed by the gvfs do_configure.
BBCLASSEXTEND += "native"
