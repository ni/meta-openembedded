inherit setuptools3
require python-pycares.inc
