inherit setuptools3
require python-aiodns.inc
